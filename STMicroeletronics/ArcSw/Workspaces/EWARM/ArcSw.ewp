# IAR project ArcSw.ewp, settings and files
configuration ArcSw (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ..\..\HAL\STM32F1xx_HAL_Driver\Inc; ..\..\HAL\STM32F1xx_HAL_Driver\Inc\Legacy; ..\..\HAL\CMSIS\Device\ST\STM32F1xx\Include; ..\..\HAL\CMSIS\Include; ..\..\API\Inc; ..\..\App\Inc; ..\..\Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ArcSw.hex
  ILINK.IlinkOutputFile: ArcSw.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App/Inc
    ../../App/Inc/: main.h
  group App/Src
    ../../App/Src/: main.c
  group Docs
    ../../Documentação/: README.txt
  group Driver/Inc
    ../../Driver/Inc/: yc_drv_adc.h yc_drv_gpio.h yc_drv_system_clock.h yc_drv_uart.h
  group Driver/Src
    ../../Driver/Src/: yc_drv_adc.c yc_drv_gpio.c yc_drv_system_clock.c
  group EWARM
    ./: startup_stm32f103xb.s
    ../../Driver/Src/: yc_drv_uart.c
  group HAL/STMicroeletronics/STM32F1xx_HAL_Driver/Inc
    ../../HAL/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_conf.h stm32f1xx_hal_cortex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_exti.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_it.h
  group HAL/STMicroeletronics/STM32F1xx_HAL_Driver/Src
    ../../HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_msp.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_it.c system_stm32f1xx.c
